# Keil uVision project Printf.uvprojx, settings and files
target Printf (6160000::V6.16::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Printf;..\..\..\..\..\AT32_Board;..\lcd;..\lv_sim_visual_studio\LVGL.Simulator\lvgl\src;..\lv_sim_visual_studio\LVGL.Simulator\lvgl\examples\porting;..\lv_sim_visual_studio\LVGL.Simulator\lvgl;..\lv_sim_visual_studio\LVGL.Simulator\lvgl\examples\styles;..\lv_sim_visual_studio\LVGL.Simulator\lvgl\examples;..\lv_sim_visual_studio\LVGL.Simulator\lvgl\demos;..\..\PrintfLvgl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_tim.c at32f4xx_spi.c at32f4xx_dac.c at32f4xx_dma.c
  group README
    ../: readme.txt
  group Lcd
    ../lcd/: st7789.c fonts.c
    ../: spi_dma.c
  group lv_src
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/nxp/: lv_gpu_nxp.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/msg/: lv_msg.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/led/: lv_led.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/list/: lv_list.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/span/: lv_span.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/widgets/win/: lv_win.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/extra/: lv_extra.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lv_porting
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/examples/porting/: lv_port_fs_template.c lv_port_disp.c lv_port_indev.c
  group examples
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/examples/styles/: lv_example_style_4.c
    ../lv_sim_visual_studio/LVGL.Simulator/lvgl/demos/stress/: lv_demo_stress.c
  group Ui
    ../lv_sim_visual_studio/LVGL.Simulator/ui/: ui_helpers.c ui.c
