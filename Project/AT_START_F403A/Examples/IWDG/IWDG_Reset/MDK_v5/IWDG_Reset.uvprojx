# Keil uVision project IWDG_Reset.uvprojx, settings and files
target IWDG_Reset (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER, AT_START_F403A_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\IWDG_Reset;..\..\..\..\..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_exti.c at32f4xx_gpio.c at32f4xx_iwdg.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c misc.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group README
    ../: readme.txt
